# IAR project Flash.ewp, settings and files
configuration FlashSign (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM360 AnalogDevices ADuCM360
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $EW_DIR$\arm\inc\AnalogDevices; ..\..\include; ..\..\common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Adc.hex
  ILINK.IlinkOutputFile: Adc.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\AnalogDevices\ADuCM360.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashWrite (ARM, debug)
  as the first configuration, except:
  group Application
    ./: FlashSign.c FlashWrite.c
  group common
    ../../common/: AdcLib.c ClkLib.c DacLib.c DioLib.c FeeLib.c GptLib.c IexcLib.c IntLib.c RstLib.c UrtLib.c WdtLib.c WutLib.c
  group Startup_Code
    ../../common/IAR/: startup_ADuCM360.s
