# Keil uVision project Flash.uvproj, settings and files
target FlashWrite (ARM-ADS)
  device: ADuCM360 Analog Devices
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x0000000-0x001FFFF) CLOCK(16000000) CPUTYPE("Cortex-M3")
  output: flash +hex
  c flags: Optim=1
  c include: ..\..\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup Code
    ../../common/Realview/: startup_ADuCM360.s
  group Application
    ./: FlashWrite.c FlashSign.c
  group common
    ../../common/: WdtLib.c WutLib.c AdcLib.c ClkLib.c DacLib.c DioLib.c FeeLib.c GptLib.c I2cLib.c IexcLib.c IntLib.c PwmLib.c RstLib.c SpiLib.c UrtLib.c
target FlashSign (ARM-ADS)
  device: ADuCM360 Analog Devices
  cpu: as above
  output: flash +hex
  c flags: Optim=1
  c include: ..\..\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
