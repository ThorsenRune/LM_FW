# IAR project FlashProtect.ewp, settings and files
configuration FlashProtect (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM360 AnalogDevices ADuCM360
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $EW_DIR$\arm\inc\AnalogDevices; ..\..\include; ..\..\common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: flashProtect.hex
  ILINK.IlinkOutputFile: FlashProtect.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\AnalogDevices\ADuCM360.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ./: FlashProtect.c
  group common
    ../../common/: AdcLib.c ClkLib.c DacLib.c DioLib.c FeeLib.c GptLib.c IexcLib.c IntLib.c RstLib.c UrtLib.c WdtLib.c WutLib.c
  group Startup_Code
    ./: startup_ADuCM360_rd_pro_IAR.s
