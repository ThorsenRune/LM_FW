# Keil uVision project FlashProtect.uvproj, settings and files
target FlashProtect (ARM-ADS)
  device: ADuCM360 Analog Devices
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x0000000-0x001FFFF) CLOCK(16000000) CPUTYPE("Cortex-M3")
  output: flashProtect +hex
  c flags: Optim=1
  c include: ..\..\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\Obj\flashProtect.sct
  group Startup Code
    ./: startup_ADuCM360_rd_pro.s
  group Application
    ./: FlashProtect.c
  group common
    ../../common/: WdtLib.c ClkLib.c DioLib.c FeeLib.c IntLib.c RstLib.c
