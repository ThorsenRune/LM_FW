# IAR project CN0300.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM360 AnalogDevices ADuCM360
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $EW_DIR$\arm\inc\AnalogDevices; ..\..\include; ..\..\common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CN0300.hex
  ILINK.IlinkOutputFile: CN0300.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\AnalogDevices\ADuCM360.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ./: FlashEraseWrite.c TempCalc.c Thermocouple_to_DAC.c
  group common
    ../../common/: AdcLib.c ClkLib.c DacLib.c DioLib.c GptLib.c IexcLib.c RstLib.c UrtLib.c WdtLib.c
  group Startup code
    ../../common/IAR/: startup_ADuCM360.s
