# IAR project PWM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM360 AnalogDevices ADuCM360
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $EW_DIR$\arm\inc\AnalogDevices; ..\..\include; ..\..\common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PWM.hex
  ILINK.IlinkOutputFile: PWM.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\AnalogDevices\ADuCM360.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ./: PWM.c
  group common
    ../../common/: ClkLib.c DioLib.c PwmLib.c WdtLib.c
  group Startup code
    ../../common/IAR/: startup_ADuCM360.s
