# Keil uVision project I2C_Master.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ADuCM360 Analog Devices
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x0000000-0x001FFFF) CLOCK(16000000) CPUTYPE("Cortex-M3")
  output: I2C_Master
  c flags: Optim=1
  c include: ..\..\..\include;..\..\..\common
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ../../../common/Realview/: startup_ADuCM360.s
  group Application
    ./: I2CDMA_Master.c
  group common
    ../../../common/: UrtLib.c WdtLib.c ClkLib.c DioLib.c DmaLib.c I2cLib.c IntLib.c
