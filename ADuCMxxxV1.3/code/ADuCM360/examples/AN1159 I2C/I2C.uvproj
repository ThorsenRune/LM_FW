# Keil uVision project I2C.uvproj, settings and files
target Master (ARM-ADS)
  device: ADuCM360 Analog Devices
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x0000000-0x001FFFF) CLOCK(16000000) CPUTYPE("Cortex-M3")
  output: I2CMaster
  c flags: Optim=1
  c include: ..\..\include;$K\ARM\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ./src/: I2Cloopback.c I2Cmaster.c I2Cslave.c I2CslaveDMA.c I2CmasterDMA.c
  group Common
    ../../common/Realview/: startup_ADuCM360.s
  group Libraries
    ../../common/: ClkLib.c DioLib.c I2cLib.c IntLib.c UrtLib.c WdtLib.c
target Slave (ARM-ADS)
  device: ADuCM360 Analog Devices
  cpu: as above
  output: Slave
  c flags: Optim=1
  c include: ..\..\include;$K\ARM\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
target MasterDMA (ARM-ADS)
  device: ADuCM360 Analog Devices
  cpu: as above
  output: MasterUART
  c flags: Optim=1
  c include: ..\..\include;$K\ARM\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
target SlaveDMA (ARM-ADS)
  device: ADuCM360 Analog Devices
  cpu: as above
  output: SlaveEEPROM
  c flags: Optim=1
  c include: ..\..\include;$K\ARM\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
target Loopback (ARM-ADS)
  device: ADuCM360 Analog Devices
  cpu: as above
  output: Loopback
  c flags: Optim=1
  c include: ..\..\include;$K\ARM\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
