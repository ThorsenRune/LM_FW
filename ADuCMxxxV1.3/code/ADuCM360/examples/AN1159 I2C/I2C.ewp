# IAR project I2C.ewp, settings and files
configuration Master (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM360 AnalogDevices ADUCM360
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $EW_DIR$\arm\inc\AnalogDevices; ..\..\include; ..\..\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2C.srec
  ILINK.IlinkOutputFile: GPTimers.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\AnalogDevices\ADuCM360.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Slave (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  OBJCOPY.OOCOutputFile: GPTimers.srec
configuration Loopback (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
configuration MasterDMA (ARM, debug)
  as the first configuration, except:
configuration SlaveDMA (ARM, debug)
  as the first configuration, except:
  group Application
    src/: I2Cloopback.c I2Cmaster.c I2CmasterDMA.c I2Cslave.c I2CslaveDMA.c
  group Common
    ../../common/IAR/: startup_ADuCM360.s
  group Libraries
    ../../common/: ClkLib.c DioLib.c I2cLib.c IntLib.c WdtLib.c
