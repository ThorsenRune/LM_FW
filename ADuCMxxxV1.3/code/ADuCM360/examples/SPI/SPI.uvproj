# Keil uVision project SPI.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ADuCM360 Analog Devices
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x0000000-0x001FFFF) CLOCK(16000000) CPUTYPE("Cortex-M3")
  output: SPI +hex
  c flags: Optim=1
  c include: ..\..\include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup file
    ../../common/Realview/: startup_ADuCM360.s
  group application
    ./: RTD_toSpi.c AD5421.c
  group Common
    ../../common/: UrtLib.c AdcLib.c ClkLib.c DioLib.c IexcLib.c IntLib.c SpiLib.c WdtLib.c DmaLib.c
