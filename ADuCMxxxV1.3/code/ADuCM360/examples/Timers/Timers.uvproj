# Keil uVision project Timers.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ADuCM360 Analog Devices
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x0000000-0x001FFFF) CLOCK(16000000) CPUTYPE("Cortex-M3")
  output: Timers +hex
  c flags: Optim=1
  c include: ..\..\include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup code
    ../../common/Realview/: startup_ADuCM360.s
  group Application
    ./: Timers.c
  group common
    ../../common/: WutLib.c ClkLib.c DioLib.c GptLib.c WdtLib.c
