# Keil uVision project ADC_DMA.uvproj, settings and files
target ADC0_DMA (ARM-ADS)
  device: ADuCM360 Analog Devices
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x0000000-0x001FFFF) CLOCK(16000000) CPUTYPE("Cortex-M3")
  output: ADC_DMA
  c flags: Optim=1
  c include: ..\..\include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ../../common/Realview/: startup_ADuCM360.s
  group application
    ./: ADC0_DMA.c ADC1_DMA.c
  group Common
    ../../common/: UrtLib.c WdtLib.c AdcLib.c ClkLib.c DmaLib.c IexcLib.c IntLib.c DioLib.c
target ADC1_DMA (ARM-ADS)
  device: ADuCM360 Analog Devices
  cpu: as above
  output: ADC_DMA
  c flags: Optim=1
  c include: ..\..\include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
