# Keil uVision project AdcExample.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ADuCM360 Analog Devices
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x0000000-0x001FFFF) CLOCK(16000000) CPUTYPE("Cortex-M3")
  output: AdcExample +hex
  c flags: Optim=1
  c include: ..\..\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup Code
    ../../common/Realview/: startup_ADuCM360.s
  group Application
    ./: ADCMeter.c
  group common
    ../../common/: WdtLib.c WutLib.c AdcLib.c ClkLib.c DacLib.c DioLib.c GptLib.c I2cLib.c IexcLib.c IntLib.c PwmLib.c RstLib.c SpiLib.c UrtLib.c DmaLib.c
