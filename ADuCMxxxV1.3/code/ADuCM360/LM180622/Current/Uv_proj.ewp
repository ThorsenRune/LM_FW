# IAR project Uv_proj.ewp, settings and files
configuration ADC0 (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM360 AnalogDevices ADuCM360
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $EW_DIR$\arm\inc\AnalogDevices; ..\..\include; ..\..\common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Adc.hex
  ILINK.IlinkOutputFile: Adc.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\AnalogDevices\ADuCM360.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ADC1 (ARM, debug)
  as the first configuration, except:
  group Application
    ./: ADC0_DMA.c ADC1_DMA.c
  group common
    ../../common/: AdcLib.c ClkLib.c DacLib.c DioLib.c DmaLib.c GptLib.c IexcLib.c IntLib.c RstLib.c UrtLib.c WdtLib.c WutLib.c
  group Startup_Code
    ../../common/IAR/: startup_ADuCM360.s
