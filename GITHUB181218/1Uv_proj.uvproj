# Keil uVision project 1Uv_proj.uvproj, settings and files
target ADC0_DMA (ARM-ADS)
  device: ADuCM360 Analog Devices
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x0000000-0x001FFFF) CLOCK(16000000) CPUTYPE("Cortex-M3")
  output: ADC_DMA
  c flags: Optim=1
  c include: ..\..\include;..\..\common
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ../../common/Realview/: startup_ADuCM360.s
  group application
    ./: main.c
  group Common
    ../../common/: UrtLib.c WdtLib.c AdcLib.c ClkLib.c IexcLib.c IntLib.c DioLib.c GptLib.c WutLib.c DacLib.c SpiLib.c DmaLib.c PwrLib.c PwmLib.c
    C:/Keil/ARM/Segger/emWin/Lib/: GUI_CM3.lib
target ADC1_DMA (ARM-ADS)
  device: ADuCM360 Analog Devices
  cpu: as above
  output: ADC_DMA
  c flags: Optim=1
  c include: ..\..\include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
